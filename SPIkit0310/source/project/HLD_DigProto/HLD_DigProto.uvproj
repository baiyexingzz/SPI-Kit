# Keil uVision project HLD_DigProto.uvproj, settings and files
target HLD_DigProto_prj (ARM-ADS)
  device: LPC1549 NXP
  cpu: IRAM(0x02000000-0x02008FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: HLD_DigProto +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: CORE_M3
  c misc: --preinclude=".\Config\Product_cfg.h"
  c include: ..\..\..\package_Lpc15xx\include;..\..\..\package_Lpc15xx\config;..\..\..\package_Lpc15xx\src\startup_code;..\..\..\package_Lpc15xx\src;..\..\..\package_Lpc15xx\include\rom;..\..\App\Coordinate\include;..\..\generic\include;..\..\hwlayer\LPC15xx\src;..\..\service\Measurement\include;..\..\service\Pwr\include;..\..\service\Statemachine\include;..\..\utilities\include;.\Config;..\..\App\UI\include;..\..\service\Calibration\include;..\..\service\usb;..\..\service\spi
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group App/coordinator
    ../../App/Coordinate/src/: app.c
  group Sysstartup
    ../../../package_Lpc15xx/src/startup_code/: sysinit.c keil_startup_lpc15xx.s
  group service
    ../../service/Statemachine/src/: statemachine.c
    ../../service/Pwr/src/: pwrctrl.c
    ../../service/Measurement/src/: measure.c
    ../../service/Calibration/src/: Calib.c
    ../../service/usb/: cdc_desc.c cdc_vcom.c
    ../../service/spi/: Package.c
  group App/UI
    ../../App/UI/src/: UI.c instruction.c
  group IOlib
    ../../../package_Lpc15xx/src/: acmp.c adc.c dac.c dma.c extint.c iap.c inmux.c interrupt.c io.c memory.c sct.c ssi.c system.c uart.c watchdog.c timer.c
